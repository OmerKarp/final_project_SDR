options:
  parameters:
    generate_options: qt_gui
    id: ex_b
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: time
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: ori_omer_demodulated_b_0
  id: ori_omer_demodulated_b
  parameters:
    fs: samp_rate
    sens: '1'
    t: time
    timeout_seconds: '3'
  states: {}
- name: ori_omer_modulate_a_0
  id: ori_omer_modulate_a
  parameters:
    fs: samp_rate
    msg: hi omer
    t: time
  states: {}

connections:
- [blocks_throttle2_0, '0', ori_omer_demodulated_b_0, '0']
- [ori_omer_modulate_a_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
