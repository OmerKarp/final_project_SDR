options:
  parameters:
    generate_options: qt_gui
    id: ex_c
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: time
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: int(samp_rate*4)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate)
    fh: '-1.0'
    max_dev: 16e3
    quad_rate: int(samp_rate*4)
    tau: '75e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/sdr/final_project_SDR/gr-ori_omer/flow_graphs/temp_output.txt
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {state: disabled}
- name: ori_omer_demodulated_b_0
  id: ori_omer_demodulated_b
  parameters:
    fs: samp_rate
    sens: '0.3'
    t: time
    timeout_seconds: '1'
  states: {}
- name: ori_omer_modulate_a_0
  id: ori_omer_modulate_a
  parameters:
    fs: samp_rate
    msg: hi omer
    t: time
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_tx_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_rcv_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', ori_omer_demodulated_b_0, '0']
- [blocks_throttle2_0, '0', analog_wfm_tx_0, '0']
- [ori_omer_modulate_a_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
