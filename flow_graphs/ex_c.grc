options:
  parameters:
    generate_options: qt_gui
    id: ex_c
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: time
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '192000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sdr/final_project_SDR/gr-ori_omer/flow_graphs/temp_moded.txt
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: ori_omer_demodulated_b_0
  id: ori_omer_demodulated_b
  parameters:
    fs: samp_rate
    sens: '0.3'
    t: time
    timeout_seconds: '1'
  states: {}
- name: ori_omer_modulate_a_0
  id: ori_omer_modulate_a
  parameters:
    fs: samp_rate
    msg: hi omer
    t: time
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '102400'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_tx_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_tx_0, '0', blocks_file_sink_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', ori_omer_demodulated_b_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', analog_wfm_tx_0, '0']
- [ori_omer_modulate_a_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
